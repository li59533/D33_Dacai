# Keil uVision project stm32f4xx.uvprojx, settings and files
target stm32f4xx (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f4xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,CMSIS_OS2,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\bsp;..\fml;..\task;..\Utilities;..\Middlewares;..\Middlewares\rttviewer;..\app;..\Drivers\CMSIS\Lib\ARM;..\Drivers\CMSIS\DSP\Include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ../Core/: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
    ../Core/Inc/: FreeRTOSConfig.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group mdl/os
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group mdl
    ../Middlewares/rttviewer/: clog.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../Middlewares/: rtos_tools.c self_def.h
  group bsp
    ../bsp/: bsp_flash.c bsp_led.c bsp_gpio.c bsp_init.c bsp_adc.c bsp_spi.c bsp_ad7682_port.c bsp_ad7682.c bsp_tim.c bsp_ad5683.c bsp_ad5683_port.c
  group fml
    ../fml/: lnprotocol.c lnprotocol_std.c system_param.c
  group task
    ../task/: first_task.c hal_task.c second_task.c task_list.c led_task.c virexc_task.c
  group uti
    ../Utilities/: crc.c version.c
  group app
    ../app/: app_sw.c app_vibration_exciter.c
software components: CMSIS:CORE 4.3.0
